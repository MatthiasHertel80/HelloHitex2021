# Keil uVision project Hello.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\tensorflow_hello_world
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group Source Group 1
    ./: main.c
    ./Board_IO/: retarget_stdio.c
  group Documentation
    ./: Abstract.txt
  group TF_Application
    ./tensorflow_hello_world/: constants.cc main_functions.cc output_handler.cc
  group TF_Models
    ./tensorflow_hello_world/: hello_world_model_data.cc
software components: CMSIS Driver:I2C SBCon 1.0.0, CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:NN Lib 3.0.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:Audio I2S 1.0.0, Native Driver:GPIO 1.0.0, Native Driver:I2C SBCon 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.4.0, Machine Learning:TensorFlow:Kernel 0.4.0
